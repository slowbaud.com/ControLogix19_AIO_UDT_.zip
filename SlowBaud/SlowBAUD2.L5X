(* Logix 5000 DataType export SlowBAUD2; software revision 19.01 *)

TYPE SlowBAUD2 :
STRUCT
   ACC : STRING;
   SERIAL : STRING;
   ACQ : STRING;
   NUL : STRING;
END_STRUCT
END_TYPE
